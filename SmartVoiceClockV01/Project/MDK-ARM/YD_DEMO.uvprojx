# Keil uVision project YD_DEMO.uvprojx, settings and files
target YD_DEMO (ARM-ADS)
  device: STM32F030C8 STMicroelectronics
  pack: Keil.STM32F0xx_DFP.1.4.0
  cpu: IROM(0x08000000,0x10000) IRAM(0x20000000,0x2000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: RTC +hex
  AfterMake: fromelf --bin ".\obj\@L.axf" --output   ".\obj\@L.bin"
  c flags: Optim=4
  c define: USE_STDPERIPH_DRIVER STM32F0xx
  c include: ..\..\Libraries\CMSIS\ST\STM32F0xx\Source\Templates\arm;..\..\Libraries\CMSIS\ST\STM32F0xx\Include;..\..\Libraries\STM32F0xx_StdPeriph_Driver\inc;..\..\Project;..\..\BSP;..\..\Libraries\CMSIS\Include;..\..\FONTS
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group Startup
    ../../Libraries/CMSIS/ST/STM32F0xx/Source/Templates/arm/: startup_stm32f030.s
  group User
    ../: main.c stm32f0xx_it.c
  group StdPeriph_Driver
    ../../Libraries/STM32F0xx_StdPeriph_Driver/src/: stm32f0xx_adc.c stm32f0xx_cec.c stm32f0xx_comp.c stm32f0xx_crc.c stm32f0xx_dac.c stm32f0xx_dbgmcu.c stm32f0xx_dma.c stm32f0xx_exti.c stm32f0xx_flash.c stm32f0xx_gpio.c stm32f0xx_i2c.c stm32f0xx_iwdg.c stm32f0xx_misc.c stm32f0xx_pwr.c stm32f0xx_rcc.c stm32f0xx_rtc.c stm32f0xx_spi.c stm32f0xx_syscfg.c stm32f0xx_tim.c stm32f0xx_usart.c stm32f0xx_wwdg.c
  group CMSIS
    ../../Libraries/CMSIS/ST/STM32F0xx/Source/Templates/: system_stm32f0xx.c
  group BSP
    ../../BSP/: usart.c led.c systick.c RTC_Time.c SEG.c VOICE.c KEY.c flash.c ADC.c
software components: CMSIS:CORE 4.1.0
